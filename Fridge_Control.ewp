# IAR project Fridge_Control.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x60
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m168a ATmega168A
  ICCAVR.newCCIncludePaths: Src; Header
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  group (top)
    Scr/: buttons.c eemem.c led_digit.c main.c menu.c modbus.c OneWireSM.c OWISWBitFunctions.c pwm_pcb.c TestData.c un_drebezg.c
